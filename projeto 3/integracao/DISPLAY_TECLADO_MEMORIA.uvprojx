# Keil uVision project DISPLAY_TECLADO_MEMORIA.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DISPLAY_TECLADO_MEMORIA +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, USE_STDPERiph_DRIVER
  c include: .\;..\..\..\..\..\Keil_v5\ARM\CMSIS\Include;..\..\..\..\..\Keil_v5\ARM\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\..\Keil_v5\ARM\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: DISPLAY_TECLADO_MEMORIA.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
